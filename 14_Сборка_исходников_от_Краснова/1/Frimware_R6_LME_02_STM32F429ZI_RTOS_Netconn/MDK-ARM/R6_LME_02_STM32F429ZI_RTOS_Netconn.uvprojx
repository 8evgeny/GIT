# Keil uVision project R6_LME_02_STM32F429ZI_RTOS_Netconn.uvprojx, settings and files
target R6_LME_02_STM32F429ZI_RTOS_Netconn (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: R6_LME_02_STM32F429ZI_RTOS_Netconn +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_FULL_LL_DRIVER
  c include: ../Inc;                                                           ../Middlewares/Third_Party/LwIP/src/include;                                                           ../Middlewares/Third_Party/LwIP/system;                                                           ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                           ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                           ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                           ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                                                           ../Middlewares/Third_Party/LwIP/src/apps/http;                                                           ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                           ../Middlewares/Third_Party/LwIP/src/include/lwip;                                                           ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                                                           ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                                                           ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                                                           ../Middlewares/Third_Party/LwIP/src/include/netif;                                                           ../Middlewares/Third_Party/LwIP/src/include/compat/posix;                                                           ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;                                                           ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;                                                           ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;                                                           ../Middlewares/Third_Party/LwIP/src/include/compat/stdc;                                                           ../Middlewares/Third_Party/LwIP/system/arch;                                                           ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ./: startup_stm32f429xx.s
    ../Src/: httpserver-netconn.c Base64.c Base64.h dbg_uart.c dbg_uart.h FIFO.h main_logic.c main_logic.h eeprom_i2c.c eeprom_i2c.h global_vars.c global_vars.h cmd_response.c cmd_response.h uart.c uart.h measurement.c measurement.h indication.c indication.h main.c freertos.c lwip.c ethernetif.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c encryption.c encryption.h log.c log.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/apps/http/: httpd.c fs.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
software components: CMSIS:CORE 5.5.0
