# Keil uVision project Frimware_R6_MK_01_STM32L151C.uvprojx, settings and files
target Frimware_R6_MK_01_STM32L151C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Frimware_R6_MK_01_STM32L151C +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L151xB
  c include: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ..\App_user; ..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Application/User
    ../App_user/: a_main.c a_main.h eeprom_i2c.c eeprom_i2c.h
    ../Src/: FIFO.h global_vars.c global_vars.h main_logic.c main_logic.h uart.c uart.h command.c command.h main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_exti.c stm32l1xx_ll_adc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_dma.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_ll_dac.c stm32l1xx_hal_i2c.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 5.6.0
