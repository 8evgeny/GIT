# Keil uVision project R_1_DTS_011M_STM32F429ZG.uvprojx, settings and files
target R_1_DTS_011M_STM32F429ZG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: R_1_DTS_011M_STM32F429ZG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_FULL_LL_DRIVER
  c include: ../Inc;                                                               ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                               ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: ST-BUS_SAI_in_out.c ST-BUS_SAI_in_out.h HDLC_Rx_low_level.c HDLC_Rx_low_level.h HDLC_Tx.c HDLC_Tx.h HDLC_Tx_low_level.c HDLC_Tx_low_level.h CRC-16_CCITT.c CRC-16_CCITT.h FIFO.h dbg_uart.c dbg_uart.h main_logic.c main_logic.h uart.c uart.h tastature.c tastature.h codec_TLV320AIC3100.c codec_TLV320AIC3100.h audio_in_out.c audio_in_out.h g711.c g711.h g711_data.h potentiometer.h volume_control.h potentiometer.c volume_control.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
