# IAR project Project.ewp, settings and files
configuration XIP_QSPI_InternalSRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750XB ST STM32H750XB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; USE_HAL_DRIVER; STM32H750xx; USE_STM32H743I_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\\STM32H743I-EVAL; ..\..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XIP_QSPI_InternalSRAM.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: QSPIflash_InternalSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XIP_QSPI_ExternalSRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; USE_HAL_DRIVER; STM32H743xx; USE_STM32H743I_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32H743I-EVAL; ..\..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\Components
  OBJCOPY.OOCOutputFile: XIP_QSPI_ExternalSRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSRAM.icf
configuration XIP_QSPI_ExternalSDRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32H743I-EVAL; ..\..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  OBJCOPY.OOCOutputFile: XIP_QSPI_ExternalSDRAM.hex
  ILINK.IlinkIcfFile: QSPIflash_ExtrenalSDRAM.icf
configuration XIP_NOR_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x60000000U; USE_HAL_DRIVER; STM32H750xx; USE_STM32H743I_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: XIP_NOR_InternalSRAM.hex
  ILINK.IlinkIcfFile: NORflash_InternalSRAM.icf
configuration XIP_NOR_ExternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: XIP_NOR_ExternalSRAM.hex
  ILINK.IlinkIcfFile: NORflash_ExtrenalSRAM.icf
configuration XIP_NOR_ExternalSDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: XIP_NOR_ExternalSDRAM.hex
  ILINK.IlinkIcfFile: NORflash_ExtrenalSDRAM.icf
configuration BootROM_ExternalSRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x68000000U; USE_HAL_DRIVER; STM32H750xx; USE_STM32H743I_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkIcfFile: ExternalSRAM_InternalSRAM.icf
configuration BootROM_ExternalSDRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0xD0000000U; USE_HAL_DRIVER; STM32H750xx; USE_STM32H743I_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkIcfFile: ExternalSDRAM_InternalSRAM.icf
  group Application/EWARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/Components
    ../../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/STM32H743I_EVAL
    ../../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
