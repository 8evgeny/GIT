# Keil uVision project Project.uvprojx, settings and files
target STM32H743I-EVAL_USBH-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.9
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743I-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H743I_EVAL,USE_USB_FS,USE_IOEXPANDER,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_io.c stm32h743i_eval_sd.c stm32h743i_eval_bus.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ioreq.c usbh_pipes.c usbh_ctlreq.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Application/User
    ../Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c usbh_diskio.c usbh_conf.c sd_diskio_dma_rtos.c
  group Drivers/STM32H7xx_HAL_Drivers
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_hcd.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_gpio.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dma.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_tim.c stm32h7xx_hal_adc.c stm32h7xx_hal_sd.c stm32h7xx_hal_uart.c stm32h7xx_hal_i2c.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_exti.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c list.c queue.c croutine.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
target STM32H743I-EVAL_USBH-HS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.9
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I-EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H743I_EVAL,USE_USB_HS,USE_IOEXPANDER,USE_IOEXPANDER
  c misc: --C99
  c include: as above
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 4.3.0
