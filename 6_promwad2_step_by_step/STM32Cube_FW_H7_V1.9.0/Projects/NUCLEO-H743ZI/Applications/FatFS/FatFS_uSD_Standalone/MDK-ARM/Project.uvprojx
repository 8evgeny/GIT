# Keil uVision project Project.uvprojx, settings and files
target STM32H743ZI_Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.9
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743ZI_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H7XX_NUCLEO_144_MB1364,ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FatFS/src;../../../../../../Drivers/BSP/Adafruit_Shield
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/BSP/STM32H743ZI_Nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
    ../Src/: stm32h7xx_nucleo_bus.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/AdaFruit_Shield
    ../../../../../../Drivers/BSP/Adafruit_Shield/: adafruit_802.c adafruit_802_sd.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_uart.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_sd.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_adc.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_gpio.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_exti.c
  group Application/User
    ../Src/: stm32h7xx_it.c sd_diskio.c main.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
software components: CMSIS:CORE 5.0.1
