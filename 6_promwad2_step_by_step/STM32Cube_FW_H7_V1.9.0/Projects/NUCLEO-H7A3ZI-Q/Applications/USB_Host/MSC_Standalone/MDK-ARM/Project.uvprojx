# Keil uVision project Project.uvprojx, settings and files
target STM32H7A3ZIQ_Nucleo_MSC_Standalone (ARM-ADS)
  device: STM32H7A3ZITxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7A3xxQ,USB_OTG_FS
  c include: ../Core/Inc;../USB_HOST/App;../USB_HOST/Target;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/is42s32800j;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/Core
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32h7a3xxq.s
  group Application/USB_Host/App
    ../USB_HOST/App/: explorer.c file_operations.c usb_host.c usbh_diskio_dma.c
  group Application/USB_Host/Target
    ../USB_HOST/Target/: usbh_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_usb.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
software components: CMSIS:CORE 4.3.0
