# Keil uVision project Project.uvprojx, settings and files
target STM32H743I-EVAL_USBD-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.9
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H7xx_CM7
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H743xx,USE_HAL_DRIVER,USE_USB_FS,USE_IOEXPANDER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/STM32_USBD_Library/Class
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Application/User
    ../Src/: usbd_conf.c usbd_desc.c stm32h7xx_it.c main.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32H7xx_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_spi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_i2c.c stm32h7xx_hal_gpio.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_i2c_ex.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_io.c stm32h743i_eval_bus.c
target STM32H743I-EVAL_USBD-HS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.9
  cpu: as above
  output: STM32H7xx_CM7
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H743xx,USE_HAL_DRIVER,USE_USB_HS,USE_IOEXPANDER
  c include: ../../../../../../Drivers/BSP/Components/Common;../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 4.3.0
