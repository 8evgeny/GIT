# Keil uVision project Project.uvprojx, settings and files
target STM32H745I-DISCO_USBD-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,USE_IOEXPANDER,CORE_CM7,CH7,USE_USB_FS
  c include: ../Common/Inc;../CM7/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H745I-DISCO;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Utilities/Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/CM7
    ../CM7/Src/: main.c stm32h7xx_it.c usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group Application/MDK-ARM
    ./: startup_stm32h745xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32H745I-DISCO
    ../../../../../../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
target STM32H745I-DISCO_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H745_Disco,CORE_CM4,CH7
  c include: ../CM4/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.1.1
