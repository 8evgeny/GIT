# IAR project Project.ewp, settings and files
configuration OSCILLO_SG_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745XI_CM4 ST STM32H745XI_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; CORE_CM4; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM4\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32H745I-DISCO; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Utilities\Fonts; ..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm4_sram.bin
  ILINK.IlinkOutputFile: STM32H745I_OSCILLO_SG_CM4.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_SRAM_OSC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OSCILLO_SG_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745XI_CM7 ST STM32H745XI_CM7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; CORE_CM7; TS_MULTI_TOUCH_SUPPORTED
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM7\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32H745I-DISCO; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Utilities\Fonts; ..\..\..\..\Utilities\CPU; ..\..\..\..\Utilities\lcd
  OBJCOPY.OOCOutputFile: STM32H745I_DISCO_CM7.hex
  ILINK.IlinkOutputFile: STM32H745I_DISCO_CM7.out
  ILINK.IlinkKeepSymbols: cm4_code
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH_OSC.icf
configuration DEMO_MENU (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745XI_CM7 ST STM32H745XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; CORE_CM7; TS_MULTI_TOUCH_SUPPORTED; MAIN_MENU
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: STM32H745I_DISCO_MENU.hex
  ILINK.IlinkOutputFile: STM32H745I_DISCO_CM7.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  group Application/EWARM
    ./: startup_stm32h745xx.s
  group Application/User/Main_Menu/CM7
    ../CM7/Src/: display_menu.c main_menu.c stm32h7xx_it_menu.c
  group Application/User/Oscillo_SignalGenerator/CM4
    ../CM4/Src/: main_oscillo_cm4.c stm32h7xx_hal_msp.c stm32h7xx_it_oscillo.c
  group Application/User/Oscillo_SignalGenerator/CM7
    ../CM7/Src/: display_oscillo.c main_oscillo_cm7.c signals_generation.c stm32h7xx_hal_msp.c stm32h7xx_it_oscillo.c touchscreen_oscillo.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
  group Drivers/BSP/STM32H745I_DISCOVERY
    ../../../../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_bus.c stm32h745i_discovery_lcd.c stm32h745i_discovery_qspi.c stm32h745i_discovery_sdram.c stm32h745i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Utilities
    ../../../../Utilities/lcd/: stm32_lcd.c
