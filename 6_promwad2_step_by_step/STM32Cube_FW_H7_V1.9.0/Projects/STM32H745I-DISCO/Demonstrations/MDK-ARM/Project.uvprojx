# Keil uVision project Project.uvprojx, settings and files
target OSCILLO_SG_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32H745I_OSCILLO_SG_CM4
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H745xx,USE_STM32H745I_DISCO,CORE_CM4,VECT_TAB_SRAM
  c include: ../Common/Inc;../CM4/Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32H745I-DISCO;../../../../Drivers/BSP/Components/Common;../../../../Utilities/LCD;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: cm4_code.s
    ./: startup_stm32h745xx.s
  group Application/User/Main_Menu/CM7
    ../CM7/Src/: display_menu.c main_menu.c stm32h7xx_it_menu.c
  group Application/User/Oscillo_SignalGenerator/CM4
    ../CM4/Src/: stm32h7xx_hal_msp.c stm32h7xx_it_oscillo.c main_oscillo_cm4.c
  group Application/User/Oscillo_SignalGenerator/CM7
    ../CM7/Src/: display_oscillo.c signals_generation.c stm32h7xx_hal_msp.c stm32h7xx_it_oscillo.c touchscreen_oscillo.c main_oscillo_cm7.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
    ../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/BSP/STM32H745I_DISCOVERY
    ../../../../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_bus.c stm32h745i_discovery_lcd.c stm32h745i_discovery_qspi.c stm32h745i_discovery_sdram.c stm32h745i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_exti.c
  group Utilities
    ../../../../Utilities/lcd/: stm32_lcd.c
target OSCILLO_SG_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H745I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H745xx,USE_STM32H745I_DISCO,CORE_CM7,TS_MULTI_TOUCH_SUPPORTED
  c include: ../Common/Inc;../CM7/Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32H745I-DISCO;../../../../Drivers/BSP/Components/Common;../../../../Utilities/LCD;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8120000 size 0xa0000
  memory RVCT5: ROM 0x81c0000 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\OSCILLO_SG_CM7\Exe\STM32H745I_DISCO_CM7.sct
  link misc: --keep=cm4_code
target DEMO_MENU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: as above
  output: STM32H745I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H745xx,USE_STM32H745I_DISCO,CORE_CM7,TS_MULTI_TOUCH_SUPPORTED,MAIN_MENU
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x100000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\DEMO_MENU\Exe\STM32H745I_DISCO_CM7.sct
software components: CMSIS:CORE 5.1.1
