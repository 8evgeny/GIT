# IAR project Project.ewp, settings and files
configuration STM32H747I_EVAL_CM7_FPU-On (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_EVAL; USE_IOEXPANDER; CORE_CM7
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM7\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H747I-EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\lcd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32H747I_EVAL_CM7_FPU_ON.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I_EVAL_CM7_FPU-Off (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  ILINK.IlinkOutputFile: STM32H747I_EVAL_CM7_FPU_OFF.out
configuration STM32H747I_EVAL_CM4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_CM4 ST STM32H747XI_CM4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_EVAL; USE_IOEXPANDER; CORE_CM4
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM4\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H747I-EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\lcd
  ILINK.IlinkOutputFile: STM32H747I_EVAL_CM4.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Application/EWARM
    ./: startup_stm32h747xx.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7
    ../CM7/Src/: button.c main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/adv7533/: adv7533.c adv7533_reg.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_bus.c stm32h747i_eval_io.c stm32h747i_eval_lcd.c stm32h747i_eval_sdram.c stm32h747i_eval_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
