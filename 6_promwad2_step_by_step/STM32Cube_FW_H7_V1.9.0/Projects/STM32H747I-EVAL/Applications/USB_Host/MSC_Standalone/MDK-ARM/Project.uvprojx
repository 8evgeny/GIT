# Keil uVision project Project.uvprojx, settings and files
target STM32H747I-EVAL_USBD-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x24000000-0x2407FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS
  c include: ../CM7/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/FatFs/Src;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Utilities/Fonts;../../../../../../Utilities/LCD;../../../../../../Utilities/Lcd_Trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Application/CM7
    ../CM7/Src/: explorer.c file_operations.c main.c menu.c stm32h7xx_it.c usbh_conf.c usbh_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/adv7533/: adv7533.c adv7533_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/STM32H747I-EVAL
    ../../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_bus.c stm32h747i_eval_io.c stm32h747i_eval_lcd.c stm32h747i_eval_sdram.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_hcd.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_i2c_ex.c
  group Middlewares/STM32_USB_Host_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/STM32_USB_Host_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Utilities
    ../../../../../../Utilities/Lcd_Trace/: lcd_trace.c
    ../../../../../../Utilities/lcd/: stm32_lcd.c
target STM32H747I-EVAL_USBD-HS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: as above
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS
  c include: ../CM7/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Utilities/Fonts;../../../../../../Utilities/LCD;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Utilities/Lcd_Trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target STM32H747I-EVAL_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IROM(0x08100000-0x81FFFFF) IRAM(0x10000000-0x10047FFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM4,CH7
  c include: ../CM4/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Middlewares/Third_Party/FatFs/src/;../../../../../../Drivers/BSP/STM32H747I_EVAL;../Common/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
software components: CMSIS:CORE 4.3.0
