# Keil uVision project MDR32F9Qx_Demo.uvprojx, settings and files
target Milandr MDR32F9Qx (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDR32F9Qx_Demo
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=47
  c include: ..\..\Library\Libraries\CMSIS\CM3\CoreSupport;..\..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\;..\..\Inc;..\..\Config;..\..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;..\..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library;..\..\src_fatfs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDR32F9Qx_FWLib
    ../../Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_wwdg.c MDR32F9Qx_adc.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_eeprom.c MDR32F9Qx_ebc.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c
  group MDR32F9Qx_USBLib
    ../../Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/USB_Library/: MDR32F9Qx_usb_device.c MDR32F9Qx_usb_CDC.c
  group MDR32F9Qx_FatFsLib
    ../../src_fatfs/: rtc.c ff.c mmc.c
  group Fonts
    ../../fonts/: Font_12x16.c Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c
  group Target
    ../../Library/Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c startup_MDR32F9Qx.s
  group User
    ../../src/: text.c MDR32F9Qx_it.c adc.c Demo_Init_MDR32F9Qx.c Demo_Init_MDR32F9Q1.c gl.c joystick.c lcd_MDR32F9Qx.c lcd_MDR32F9Q1.c leds.c Main.c Menu.c Menu_gl.c Menu_leds.c Menu_text.c Menu_time.c Menu_tsensor.c Menu_uart.c Menu_VCOM.c Menu_lowpower.c systick.c Menu_uSDFlash.c
software components: CMSIS:CORE 5.4.0
