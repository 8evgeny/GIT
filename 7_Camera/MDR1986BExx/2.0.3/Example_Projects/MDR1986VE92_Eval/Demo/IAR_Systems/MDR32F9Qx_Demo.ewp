# IAR project MDR32F9Qx_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\inc; ..\..\..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc; ..\..\..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library; ..\..\..\Library\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc; ..\..\..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\iar; ..\..\src_fatfs
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MDR32F9Qx_Demo.hex
  ILINK.IlinkOutputFile: MDR32F9Qx_Demo.out
  ILINK.IlinkIcfFile: Milandr_MDR32F9Qx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group Fonts
    ../../fonts/: Font_12x16.c Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c
  group MDR32F9Qx_FatFsLib
    ../../src_fatfs/: diskio.h ff.c ff.h ffconf.h integer.h mmc.c rtc.c rtc.h
  group MDR32F9Qx_FWLib
    ../../../Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group MDR32F9Qx_USBLib
    ../../../Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/USB_Library/: MDR32F9Qx_usb_CDC.c MDR32F9Qx_usb_device.c
  group Target
    ../../../Library/Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/iar/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group User
    ../../src/: adc.c Demo_Init_MDR32F9Q1.c Demo_Init_MDR32F9Qx.c gl.c joystick.c lcd_MDR32F9Q1.c lcd_MDR32F9Qx.c leds.c Main.c MDR32F9Qx_it.c Menu.c Menu_gl.c Menu_leds.c Menu_lowpower.c Menu_text.c Menu_time.c Menu_tsensor.c Menu_uart.c Menu_VCOM.c systick.c text.c
