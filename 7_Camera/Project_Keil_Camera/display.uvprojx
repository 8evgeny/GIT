# Keil uVision project display.uvprojx, settings and files
target display (6160000::V6.16::ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: display +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./UserCode/: main.h
  group src
    ./UserCode/: logic.cpp main.cpp milandr.cpp SSM2166_MicPreamp.cpp TPA3255_Amplifier.cpp inputSig.cpp outputSig.cpp
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:USB Device:Custom 1.0.0, CMSIS Driver:USB Host:Custom 1.0.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.0.3, Drivers:IWDG 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3
