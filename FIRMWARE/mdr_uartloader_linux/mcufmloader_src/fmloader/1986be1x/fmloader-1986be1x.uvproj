# Keil uVision project fmloader-1986be1x.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: fmloader-1986be1x +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x20103400 size 0x800
  memory RVCT9: RAM 0x20103c00 size 0x400
  group Source Group 1
    ./src/: startup_1986be1x_ccarm.s fmloader-1986be1x-main.c
