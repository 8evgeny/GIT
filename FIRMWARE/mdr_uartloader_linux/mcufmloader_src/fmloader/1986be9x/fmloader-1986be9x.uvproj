# Keil uVision project fmloader-1986be9x.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: fmloader-1986be9x +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x20007800 size 0x400
  memory RVCT9: RAM 0x20007c00 size 0x400
  group Source Group 1
    ./src/: startup_1986be9x_ccarm.s fmloader-1986be9x-main.c
