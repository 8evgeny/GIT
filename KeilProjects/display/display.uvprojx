# Keil uVision project display.uvprojx, settings and files
target display (6160000::V6.16::ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: display +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./UserCode/: gpio.c mt20s4.c rcc_delay.c var.c main.cpp logic.cpp usb.cpp checkLCD_BUZZER.cpp
  group inc
    ./UserCode/: gpio.h main.h RTE_Components.h usb.h
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:USB Device:Custom 1.0.0, CMSIS Driver:USB Host:Custom 1.0.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.0.3, Drivers:IWDG 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:TIMER 2.0.3, Drivers:USB Library 2.0.3, Drivers:USB 2.0.3
