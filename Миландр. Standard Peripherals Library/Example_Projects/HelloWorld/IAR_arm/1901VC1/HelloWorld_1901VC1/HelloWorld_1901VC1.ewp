# IAR project HelloWorld_1901VC1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1901VC1 Milandr MDR1901VC1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32Fx\CoreSupport\CM3; ..\..\Libraries\CMSIS\MDR32Fx\DeviceSupport\MDR1901VC1T\inc; ..\..\Libraries\CMSIS\MDR32Fx\DeviceSupport\MDR1901VC1T\startup\iar; ..\..\Libraries\SPL\MDR32Fx\inc; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR32Fx/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group src
    ./: main.c MDR32F9Qx_config.h
  group Startup
    ../../Libraries/CMSIS/MDR32Fx/DeviceSupport/MDR1901VC1T/startup/iar/: startup_MDR1901VC1T.s system_MDR1901VC1T.c system_MDR1901VC1T.h
