# IAR project HelloWorld_1986VE1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE1 Milandr MDR1986VE1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 36
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32Fx\CoreSupport\CM1; ..\..\Libraries\CMSIS\MDR32Fx\DeviceSupport\MDR1986VE1T\inc; ..\..\Libraries\CMSIS\MDR32Fx\DeviceSupport\MDR1986VE1T\startup\iar; ..\..\Libraries\SPL\MDR32Fx\inc; ..; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld_1986VE1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR32Fx/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group src
    ./: main.c MDR32F9Qx_config.h
  group Startup
    ../../Libraries/CMSIS/MDR32Fx/DeviceSupport/MDR1986VE1T/startup/iar/: startup_MDR1986VE1T.s system_MDR1986VE1T.c system_MDR1986VE1T.h
