# IAR project HelloWorld_1986VE4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE4 Milandr MDR1986VE4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR1986BE4\CoreSupport; ..\..\Libraries\CMSIS\MDR1986BE4\DeviceSupport\inc; ..\..\Libraries\CMSIS\MDR1986BE4\DeviceSupport\startup\iar; ..\..\Libraries\SPL\MDR1986BE4\inc; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR1986BE4/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group src
    ./: main.c MDR32F9Qx_config.h
  group Startup
    ../../Libraries/CMSIS/MDR1986BE4/DeviceSupport/startup/iar/: startup_MDR1986BE4.S system_MDR1986BE4.c system_MDR1986BE4.h
