# IAR project HelloWorld_1986VE8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE8 Milandr MDR1986VE8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32F8\CoreSupport; ..\..\Libraries\CMSIS\MDR32F8\DeviceSupport\inc; ..\..\Libraries\CMSIS\MDR32F8\DeviceSupport\startup\iar; ..\..\Libraries\SPL\MDR32F8\inc; ..\..\Libraries\SPL\MDR32F8\; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR32F8/src/: mdr32f8_clkctrl.c mdr32f8_port.c
    ../../Libraries/SPL/MDR32F8/: spec.c
  group src
    ./: main.c mdr32f8_config.h
  group Startup
    ../../Libraries/CMSIS/MDR32F8/DeviceSupport/startup/iar/: startup_1986ve8t.s system_1986ve8t.c system_1986ve8t.h
