# IAR project HelloWorld_DualCore_1986VK01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VK01 Milandr MDR1986VK01
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32F2C10\CoreSupport; ..\..\Libraries\CMSIS\MDR32F2C10\DeviceSupport\inc; ..\..\Libraries\CMSIS\MDR32F2C10\DeviceSupport\startup\iar; ..\..\Libraries\SPL\MDR32F2C10\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR32F2C10/src/: MDR32F2C10_port.c
  group src
    ./: main.c MDR32F2C10_config.h mutex.s
  group Startup
    ../../Libraries/CMSIS/MDR32F2C10/DeviceSupport/startup/iar/: startup_MDR32F2C10_DC.s system_MDR32F2C10.c system_MDR32F2C10.h
