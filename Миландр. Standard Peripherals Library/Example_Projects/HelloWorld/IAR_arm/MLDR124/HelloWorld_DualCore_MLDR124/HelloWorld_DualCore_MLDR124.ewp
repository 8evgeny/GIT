# IAR project HelloWorld_DualCore_MLDR124.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MLDR124 Milandr MLDR124
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MLDR124\CoreSupport; ..\..\Libraries\CMSIS\MLDR124\DeviceSupport\inc; ..\..\Libraries\CMSIS\MLDR124\DeviceSupport\startup\iar; ..\..\Libraries\SPL\MLDR124\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MLDR124/src/: mldr124_port.c
  group src
    ./: main.c mldr124_config.h mutex.s
  group Startup
    ../../Libraries/CMSIS/MLDR124/DeviceSupport/startup/iar/: startup_mldr124_DC.s system_mldr124.c system_mldr124.h
