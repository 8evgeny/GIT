# IAR project LCD_Example.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: MLDR187 Milandr MLDR187
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCIncludePath2: MLDR187_SPL\inc
  OBJCOPY.OOCOutputFile: Interrupt_Example.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MLDR187_TCMA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group (top)
    src/: Font_ASCII_6x8.c interrupt.c lcd_MLDR187.c main.c text.c
  group Lib
    MLDR187_SPL/src/: MLDR187_adc.c MLDR187_adcui.c MLDR187_bkp.c MLDR187_clk_msr.c MLDR187_crc.c MLDR187_dma.c MLDR187_eeprom.c MLDR187_gpio.c MLDR187_i2c.c MLDR187_iso7816.c MLDR187_iwdg.c MLDR187_otp.c MLDR187_power.c MLDR187_rng.c MLDR187_rst_clk.c MLDR187_sensors.c MLDR187_ssp.c MLDR187_timer.c MLDR187_uart.c MLDR187_wwdg.c
